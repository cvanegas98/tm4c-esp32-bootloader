# Keil uVision project test.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  AfterMake: C:\Users\cvent\AppData\Local\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin --output .\Objects\test.bin .\Objects\test.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\bootloader\inc;.\vendor
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./bootloader/test/: flash_write_bench.c flash_erase_bench.c journal_read_bench.c journal_append_bench.c
    ./vendor/: tm4c123gh6pm.h startup.s
    ./bootloader/src/: flash.c journal.c crc32.c
    ./bootloader/inc/: journal.h crc32.h
